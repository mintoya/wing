File: kicad/swd.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: idk
Parts:
- renumbered CH5 to CH1, D5 to D1
